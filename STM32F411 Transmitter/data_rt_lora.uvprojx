# Keil uVision project data_rt_lora.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: data_rt_lora
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE
  c include: .\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.c
  group User
    ./: main.c
  group Startup
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Include/: startup_stm32f411xe.s
